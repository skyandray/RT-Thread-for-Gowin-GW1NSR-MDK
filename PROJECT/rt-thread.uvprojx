# Keil uVision project rt-thread.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: ..\tools\hex2bin.exe  .\Objects\rt-thread.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RTE_USING_FINSH
  c include: ..\CORE;..\PERIPHERAL\Includes;..\SYSTEM;..\USER;..\KERNEL\inc;..\KERNEL\inc\libc;..\finsh
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../STARTUP/: startup_gw1ns4c.s
  group SYSTEM
    ../SYSTEM/: system_gw1ns4c.c
  group PERIPHERAL
    ../PERIPHERAL/Sources/: gw1ns4c_gpio.c gw1ns4c_i2c.c gw1ns4c_misc.c gw1ns4c_rtc.c gw1ns4c_spi.c gw1ns4c_syscon.c gw1ns4c_timer.c gw1ns4c_uart.c gw1ns4c_wdog.c
  group KERNEL
    ../KERNEL/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c board.c
    ../CORE/: context_rvds.S cpuport.c
    ../finsh/: cmd.c msh.c shell.c
  group USER
    ../USER/: gw1ns4c_it.c main.c
